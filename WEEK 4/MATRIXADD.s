/*#Matrix Addition of 3*3
#MLA R1,R2,R3,R4 	---> R1 = R2*R3+R4
#LSL #n          	---> LOGICAL LEFT SHIFT BY n --> MULTIPLY BY 2^n
R3 ---> ROW NUMBER {0,1,2}
R4 ---> COLUMN NUMBER {0,1,2}
R0 ---> 1ST ELEMENT ADDRESS
R10 ---> 3 # NO.OF ELEMENTS IN A ROW

TO FIND THE ADDRESS OF ANY ELEMENT : R11 = (R3*R10+R4) LSL #2 ---> R0+R11





*/

.DATA
A:.WORD 1,2,3,4,5,6,7,8,9
B:.WORD 1,2,3,4,5,6,7,8,9
C:.WORD 0,0,0,0,0,0,0,0,0

.TEXT
LDR R0,=A
LDR R1,=B
LDR R2,=C
MOV R3,#0   ;INNER LOOP COUNT I INDEX 
MOV R4,#0   ;OUTER LOOP J INDEX
MOV R10,#3  ;NUMBER OF ELEMENTS IN ROW
MOV R12,#4

LOOP1:MLA R11,R3,R10,R4
MOV R11,R11,LSL #2

LDR R5,[R0,R11]    ;RO value not updated
LDR R6,[R1,R11]    ;R1 value not updated

ADD R7,R5,R6
STR R7,[R2,R11]

ADD R4,R4,#1
CMP R4,#3
BNE LOOP1
MOV R4,#0
ADD R3,R3,#1
CMP R3,#3
BNE LOOP1
SWI 0X11



