.DATA
A:.WORD 1,2,3,4,5,6,7,8,9
B:.WORD 1,2,3,4,5,6,7,8,9
C:.WORD 0,0,0,0,0,0,0,0,0

.TEXT
LDR R0,=A
LDR R1,=B
LDR R2,=C
MOV R3,#0   ;INNER LOOP COUNT I INDEX 
MOV R4,#0   ;OUTER LOOP J INDEX
MOV R10,#3  ;NUMBER OF ELEMENTS IN ROW
MOV R12,#4
MOV R9,#0
MOV R13,#0
MOV R9,#0

LOOP2:
MLA R8,R3,R10,R13
MOV R8,R8,LSL #2

LOOP1:
MLA R11,R3,R10,R4
MLA R12,R14,R10,R9

MOV R11,R11,LSL #2
MOV R12,R12,LSL #2
LDR R5,[R0,R11]    ;RO value not updated
LDR R6,[R1,R12]    ;R1 value not updated
MLA R7,R5,R6,R7
ADD R4,R4,#1
ADD R14,R14,#1
CMP R4,#3
BNE LOOP1

STR R7,[R2,R8]
MOV R7,#0
MOV R4,#0  
MOV R14,#0
ADD R9,R9,#1
ADD R13,R13,#1
CMP R13,#3
BNE LOOP2

MOV R9,#0
MOV R13,#0
ADD R3,R3,#1
CMP R3,#3
BNE LOOP2

SWI 0X11