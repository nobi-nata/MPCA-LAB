.DATA 
A:.WORD 4,8,2,4,-7,8,1,3,-5   
B:.WORD 0
.TEXT
LDR R0,=A
LDR R1,=B
MOV R2,#0 ;STORES NORM
MOV R6,#0 ;COUNTER I FOR OUTER LOOP 
MOV R7,#0 ;COUNTER J FOR INNER LOOP

LOOP1:
MOV R3,#0
MOV R7,#0
LOOP2:
LDR R4,[R0],#4
CMP R4,#0
BGE LOOP3
MVN R4,R4
ADD R4,R4,#1
LOOP3:
ADD R7,R7,#1
ADD R3,R3,R4
CMP R7,#3
BNE LOOP2
CMP R2,R3
BGE LOOP4
MOV R2,R3
LOOP4:
ADD R6,R6,#1
CMP R6,#3
BNE LOOP1

STR R2,[R1]
SWI 0x11